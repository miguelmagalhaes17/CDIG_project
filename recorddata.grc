options:
  parameters:
    author: miguel
    generate_options: qt_gui
    id: recorddata
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: central_freq
  id: variable
  parameters:
    value: '2462000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/miguel/Documents/CDIG_project/plutotofile.dat
    type: complex
    unbuffered: 'True'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: central_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
